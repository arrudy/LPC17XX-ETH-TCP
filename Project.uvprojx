# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x2007c000 size 0x4000
  memory RVCT7: RAM 0x20080000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x8000
  scatter file: .\Project.sct
  group Source Group 1
    ./: main.c string_extra.c string_extra.h uart_handle.h uart_handle.c eth_handle.c eth_handle.h uart_parser.c uart_serializer.c slab_alloc.c slab_alloc.h uart_parser.h uart_serializer.h command.h layer_void.c layer_cmd.h layer_sim.h layer_void.h if_dispatcher.h tcp_server.h retarget.c tcp_server.c command.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:Ethernet MAC 2.12.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:USART 2.10.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0, Network:API 2.3.0, Network:CORE 2.3.0, Network:Driver:Ethernet 2.3.0, Network:Interface:Ethernet 2.3.0, Network:RTOS 2.3.0
